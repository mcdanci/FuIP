# Keil uVision project fuip.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC-STC12
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: fuip +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\fu_ip;.\sys;.\enc28j60
  group Source Group 1
    ./: fuip.c
  group fuip
    ./fu_ip/: fu_config.c fu_enthernet.c fu_arp.c fu_ip.c fu_icmp.c fu_udp.c fu_tcp.c fu_send.c fu_receive.c fu_app.c fu_http.c
  group sys
    ./sys/: spi.c delay.c mcuinit.c
  group enc28j60
    ./enc28j60/: enc28j60.c
